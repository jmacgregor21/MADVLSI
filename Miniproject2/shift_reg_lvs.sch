v {xschem version=2.9.9 file_version=1.2 }
G {}
K {}
V {}
S {}
E {}
N 340 -600 630 -600 { lab=VDD}
N 850 -600 1150 -600 { lab=VDD}
N 330 -600 340 -600 { lab=VDD}
N 330 -620 330 -600 { lab=VDD}
N 1510 -250 1510 -240 { lab=GND}
N 1510 -260 1510 -250 { lab=GND}
N 1160 -260 1160 -240 { lab=GND}
N 800 -260 800 -240 { lab=GND}
N 450 -260 450 -240 { lab=GND}
N 220 -180 1280 -180 { lab=clk}
N 1440 -260 1440 -180 { lab=clk}
N 1090 -260 1090 -180 { lab=clk}
N 730 -260 730 -180 { lab=clk}
N 380 -260 380 -180 { lab=clk}
N 80 -500 230 -500 { lab=D}
N 80 -500 80 -400 { lab=D}
N 530 -500 580 -500 { lab=#net1}
N 530 -400 580 -400 { lab=#net2}
N 880 -500 940 -500 { lab=#net3}
N 880 -400 940 -400 { lab=#net4}
N 1240 -500 1290 -500 { lab=#net5}
N 1240 -400 1290 -400 { lab=#net6}
N 1590 -500 1610 -500 { lab=Qout}
N 1590 -400 1620 -400 { lab=Qoutb}
N 1150 -600 1390 -600 { lab=VDD}
N 1280 -180 1440 -180 { lab=clk}
N 630 -600 850 -600 { lab=VDD}
N 60 -500 80 -500 { lab=D}
N 220 -400 230 -400 { lab=#net7}
N 150 -340 150 -320 { lab=GND}
N 150 -470 150 -460 { lab=VDD}
C {/home/madvlsi/Documents/Miniproject2/dflipflop.sym} 190 -200 0 0 {name=X1}
C {/home/madvlsi/Documents/Miniproject2/dflipflop.sym} 540 -200 0 0 {name=X2}
C {/home/madvlsi/Documents/Miniproject2/dflipflop.sym} 900 -200 0 0 {name=X3}
C {/home/madvlsi/Documents/Miniproject2/dflipflop.sym} 1250 -200 0 0 {name=X4}
C {madvlsi/vdd.sym} 330 -620 0 0 {name=l1 lab=VDD}
C {madvlsi/gnd.sym} 450 -240 0 0 {name=l2 lab=GND}
C {madvlsi/gnd.sym} 800 -240 0 0 {name=l3 lab=GND}
C {madvlsi/gnd.sym} 1160 -240 0 0 {name=l4 lab=GND}
C {madvlsi/gnd.sym} 1510 -240 0 0 {name=l5 lab=GND}
C {devices/ipin.sym} 60 -500 0 0 {name=p1 lab=D}
C {devices/ipin.sym} 220 -180 0 0 {name=p2 lab=clk
}
C {devices/opin.sym} 1610 -500 0 0 {name=p3 lab=Qout}
C {devices/opin.sym} 1620 -400 0 0 {name=p4 lab=Qoutb}
C {/home/madvlsi/Documents/inverter_tutorial/inverter.sym} 10 -400 0 0 {name=X5}
C {madvlsi/vdd.sym} 150 -470 0 0 {name=l6 lab=VDD}
C {madvlsi/gnd.sym} 150 -320 0 0 {name=l7 lab=GND}
